# Keil uVision project DIY.uvprojx, settings and files
target DIY (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: DIY +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,ARM_MATH_CM7, __TARGET_FPU_VFP, __FPU_PRESENT=1, __ARM_COMPAT_USAT
  c include: ../Core/Inc;../USB_Device/App;../USB_Device/Target;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;..\APP;..\BSP;..\MODULES;..\Middlewares\ST\ARM\DSP\Inc;..\APP\cmd_task;..\APP\motor_task;..\BSP\adc;..\BSP\can;..\BSP\dwt;..\BSP\flash;..\BSP\log;..\BSP\usart;..\MODULES\algorithm\crc;..\MODULES\can_comm;..\MODULES\controller;..\MODULES\daemon;..\MODULES\encoder\MT6816;..\MODULES\flash;..\MODULES\led;..\MODULES\motor;..\MODULES\vofa;..\MODULES\algorithm;..\MODULES\encoder;..\Middlewares\ST\ARM\DSP\Lib
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c adc.c dma.c fdcan.c rng.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_rng.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group APP
    ../APP/: robot.c
    ../APP/cmd_task/: cmd_task.c
    ../APP/motor_task/: motor_task.c
  group BSP
    ../BSP/adc/: bsp_adc.c
    ../BSP/can/: bsp_can.c
    ../BSP/dwt/: bsp_dwt.c
    ../BSP/flash/: bsp_flash.c
    ../BSP/log/: bsp_log.c
    ../BSP/usart/: bsp_usart.c
  group MODULES
    ../MODULES/algorithm/crc/: crc8.c crc16.c
    ../MODULES/can_comm/: can_driver.c
    ../MODULES/controller/: pid.c
    ../MODULES/daemon/: daemon.c
    ../MODULES/encoder/MT6816/: mt6816_encoder.c
    ../MODULES/flash/: flash_driver.c
    ../MODULES/led/: led.c
    ../MODULES/motor/: BLDCMotor.c FOCMotor.c Motor_ADC.c trapTraj.c
    ../MODULES/vofa/: vofa.c
software components: CMSIS:CORE 5.5.0
